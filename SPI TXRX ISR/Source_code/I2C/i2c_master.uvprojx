# Keil uVision project i2c_master.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: i2c_master
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\inc;.\userApp;.\drivers;..\led
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group drivers
    ./drivers/: hal_gpio_driver.c hal_i2c_driver.c hal_gpio_driver.h hal_i2c_driver.h
  group userApp
    ./userApp/: i2c_main.c i2c_main.h i2c_int_handler.c
    ../led/: led.c led.h
software components: CMSIS:CORE 4.3.0, Device:Startup 2.4.2
